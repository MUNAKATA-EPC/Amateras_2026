//--------------------------------------------------------------------------------
// Title: Main - [ NewFile-01 ]
// Build:DAISEN C-Style for TJ3B  [ Ver.20190706 ] - [ Build_V190617 ]
//--------------------------------------------------------------------------------
// SetupVal:111111-110030-000000,cmt:
// CN01:Ball
// CN02:Line
// CN03:L-Touch
// CN04:R-Touch
// CN05:C-Touch
// CN06:
// CN07:
// CN08:
// CN09:RED3
// CN10:RED2
//--------------------------------------------------------------------------------
#include "D_Main.h"
#include "D_I2C.h"
#include "D_SIO.h"
#include "D_EIO.h"
//--------------------------------------------------------------------------------
// Program Name : NewFile-01.C
//--------------------------------------------------------------------------------
void user_main(void)
{
  while (TRUE) {
    sub_io_set_gV(1, VAR_A, 0);
    if (gAD[CN1] < 306) {
    } else {
    }
    if (gAD[CN3] > 10  &&  gAD[CN3] < 350 || gAD[CN3] > 370) {
      set_Led(1, LED_OFF);
      motor(-50, -50);
    } else {
      set_Led(1, LED_ON);
      motor(50, 50);
    }
    if (gAD[CN1] > 10  &&  gAD[CN1] < 350 || gAD[CN1] > 370) {
      set_Led(0, LED_OFF);
    } else {
      set_Led(0, LED_ON);
    }
  }
}
//--------------------------------------------------------------------------------
